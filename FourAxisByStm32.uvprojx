# Keil uVision project FourAxisByStm32.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FourAxisByStm32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\RTE\Device\STM32F103C8;.\Lib;.\IMU;.\RTE;..\test1(姿态解算)
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ./Lib/: Delay.cpp F103_PWM.cpp GPIO.cpp I2C.cpp Interrupt.cpp TaskManager.cpp Timer.cpp USART.cpp LED.cpp eeprom.cpp SPI.cpp NRF24L01.cpp Flash.cpp
  group AHRS
    ./IMU/: HMC5883L.cpp mpu6050.cpp attitude.cpp IMU.cpp
  group APP
    ./: main.cpp Moto_PWM.cpp
    ./Lib/: Control.cpp Communication.cpp
    ./IMU/: CRC.cpp
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
